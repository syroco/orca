Commit message: mutexes are now in private impl

File: examples/lwr.urdf (robot description, URDF)
Before this commit: robot lwr, 11 links, 10 joints
Joints:
- joint world_joint: limit (none) -> lower=0 upper=0 effort=400000 velocity=0
